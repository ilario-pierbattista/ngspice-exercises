* Title: PI attenuator

* Netlist
V1 a 0 5V
R1 a 0 100
R2 a b 100
R3 b 0 100

* Control
.control
op
print all
.endc
